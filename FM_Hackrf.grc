options:
  parameters:
    author: Admin
    generate_options: qt_gui
    id: FM_RTL
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Gain_rf
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '48'
    value: '30'
  states: {}
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    start: 200e3
    step: 10e3
    stop: 1000e3
    value: 240e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 50e6
    step: 0.5e6
    stop: 5500e6
    value: 93.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '42'
    quad_rate: '2016000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bandwidth/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: bandwidth/4
    win: window.WIN_HAMMING
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: TX/RX
    balance0: '0'
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    devname: hackrf
    overall_gain0: Gain_rf
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_correctiq_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_correctiq_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [soapy_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
